# Repository erikdesjardins/annoyance

File README.md:

# annoyance
Basic guitar/instrument-level tesla coil interrupter.

Based on https://kaizerpowerelectronics.dk/tesla-coils/musical-sstcdrsstc-interrupter/.

## KiCad design src/annoyance.kicad_pcb

Parts:
C1, C6, C8, C9: 100n; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C2, C3, C4, C5, C7: 1n; C_Rect_L7.2mm_W2.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C_IN1, C_IN2: 1u; C_Rect_L7.2mm_W5.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C_PWR1, C_PWR2: 2200u; CP_Radial_D10.0mm_P5.00mm
D1, D2, D3, D4: 1N4148; D_T-1_P5.08mm_Horizontal
D5: 1N5817; D_DO-41_SOD81_P10.16mm_Horizontal
D_OUT1: LED; LED_D5.0mm
D_PWR_IND1: LED; SolderWire-0.1sqmm_1x02_P3.6mm_D0.4mm_OD1mm
J1: AudioJack2_SwitchT; SolderWire-0.1sqmm_1x03_P3.6mm_D0.4mm_OD1mm
J2: Barrel_Jack; SolderWire-0.1sqmm_1x02_P3.6mm_D0.4mm_OD1mm
L_PWR1, L_PWR2: 2.2m; L_Radial_D7.0mm_P3.00mm
R1, R2, R4: 100k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R3, R5: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
RV_G1: 1k; SolderWire-0.1sqmm_1x03_P3.6mm_D0.4mm_OD1mm
RV_PULSE_WIDTH1: 10k; SolderWire-0.1sqmm_1x03_P3.6mm_D0.4mm_OD1mm
R_F1: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R_G1: 100; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R_IN1, R_IN2: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R_OUT1: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R_OUT_PUP_1: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R_PWR_IND1: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R_REF1, R_REF2: 10k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R_X1, R_X2: 100; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
R_Y1, R_Y2, R_Y3: 1k; R_Axial_DIN0204_L3.6mm_D1.6mm_P5.08mm_Horizontal
U1, U3: ICM7555xP; DIP-8_W7.62mm_Socket
U2: TLC274; DIP-14_W7.62mm_Socket

Connections:
+12V: J2.1, L_PWR1.1
/AUDIO+: C_IN2.1, J1.2 (T)
/AUDIO-: C_IN1.1, J1.1 (S), J1.3 (TN)
/PULSE: R_OUT1.1, U3.3 (Q)
/SIGNAL: R_Y3.2, U1.2 (TR), U2.8
GND: C1.2, C3.2, C6.2, C7.2, C8.1, C9.2, C_PWR1.2, C_PWR2.2, D2.2 (A), D4.2 (A), D_OUT1.1 (K), D_PWR_IND1.1 (K), J2.2, R_REF2.2, U1.1 (GND), U2.11 (V-), U3.1 (GND)
unnamed: C2.1, D3.2 (A), D4.1 (K), R4.1, R_IN2.2, U2.3 (+)
unnamed: C2.2, D1.2 (A), D2.1 (K), R2.1, R_IN1.2, U2.5 (+)
unnamed: C3.1, R1.1, U1.6 (THR), U1.7 (DIS)
unnamed: C4.1, C5.1, U1.3 (Q)
unnamed: C4.2, C5.2, D5.2 (A), R3.1, U3.2 (TR)
unnamed: C7.1, R5.1, U3.6 (THR), U3.7 (DIS)
unnamed: C8.2, R_REF1.2, R_REF2.1, U2.12 (+)
unnamed: C_IN1.2, R_IN1.1
unnamed: C_IN2.2, R_IN2.1
unnamed: C_PWR1.1, L_PWR1.2, L_PWR2.1
unnamed: D_OUT1.2 (A), R_OUT1.2, R_OUT_PUP_1.2
unnamed: D_PWR_IND1.2 (A), R_PWR_IND1.2
unnamed: R2.2, R4.2, R_Y2.1, U2.13 (-), U2.14
unnamed: R5.2, RV_PULSE_WIDTH1.1
unnamed: RV_G1.2, R_F1.1, U2.6 (-)
unnamed: RV_G1.3, R_G1.2
unnamed: R_F1.2, R_X1.1, U2.7
unnamed: R_G1.1, R_Y1.1, U2.2 (-)
unnamed: R_X1.2, R_Y3.1, U2.9 (-)
unnamed: R_X2.1, R_Y1.2, U2.1
unnamed: R_X2.2, R_Y2.2, U2.10 (+)
VCC: C1.1, C6.1, C9.1, C_PWR2.1, D1.1 (K), D3.1 (K), D5.1 (K), L_PWR2.2, R1.2, R3.2, RV_PULSE_WIDTH1.2, R_OUT_PUP_1.1, R_PWR_IND1.1, R_REF1.1, U1.4 (R), U1.8 (VCC), U2.4 (V+), U3.4 (R), U3.8 (VCC)

Notes on the sheet:
Amplification
Sizing: set off-state voltage across LED to ~1V (forms voltage divider with R_OUT1 when off; this speeds up switching, per app. notes)
Sizing: 1us pulse on falling edge (shortest pulse for detection) Note that reverse leakage through the schottky is quite significant, and requires 2x the capacitance
Sizing: as big as possible
Note: all R_X?, R_Y? must be the same value
"Output Power"
Sizing: ~3-20x gain in first stage (gain = 1+2R_F/R_G) Pins: resistance HIGH @ 0 pos. Taper: linear (results in hyperbolic gain)
Sizing: 10% attenuation (DC return path to ground)
Sizing: ~30kHz low-pass filter
Component Notes: - TLC274 is actually TLC074 - output LED is actually IF-E96E (fiber optic transmitter) - resistors in amplification block must be well matched (<= 1% tolerance) - pF caps are ceramic; otherwise - bipolar caps are film (not ceramic to avoid microphone effects); and - polarized caps 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
Pulse Generation
Sizing: ~15Hz high-pass filter
Sizing: 100us pulse width (10kHz low-pass "aliasing filter")
Sizing: 1-11us pulse width (1-11% duty cycle @ 10kHz) Pins: resistance LOW @ 0 pos. Taper: linear
Sizing: per app. notes (close for decoupling)
"Input Gain"
Sizing: 10x gain in second stage (gain = R_Y/R_X)
Power Conditioning
Output
Note: want ~10ohm resistance to limit inrush to 1A, but inductor generally has enough internal resistance
Sizing: limit current to 10mA
Sizing: limit on-state current to 10mA (app. notes say 20mA; but "official" transmitter only seems to drive at 50%) (and this avoids unusual resistor values)

Board: 2 copper layers, 48 parts (0 on the bottom side), 28 nets.

## Commit log

2022-04-10 add link to original design
2022-04-10 init kicad project
2022-04-11 init schematic
2022-04-11 use PWR_FLAG properly, now no ERC violations
2022-04-11 assign footprints
2022-04-11 improve footprints
2022-04-12 add notes
2022-04-13 change paper size to letter
2022-04-13 remove output indicator LED
2022-04-13 properly connect pot, add pullup to LED output per application notes
    it makes switching faster, presumably because the LED's internal capacitance is never
    discharged
    https://www.digikey.ca/en/htmldatasheets/production/1123534/0/0/2/if-e96e.html
2022-04-13 tweak pullup resistor value
    since the output gets connected to ground on low signal,
    we end up with a voltage divider. 4.7k produces ~1.1V across the
    transmitter, slightly below the ~1.5-1.7V needed to emit, but enough
    that it should speed up switching times by ~2/3, assuming it's linear
2022-04-14 add resistor sizing notes to power/output stages
2022-04-14 more sizing/positioning notes
2022-04-16 overhaul amplification stage: input RC filter, use instrumentation amplifier, variable gain, switch to single-supply chip
2022-04-16 add decoupling cap across opamp supply per app notes
2022-04-16 use buffered Vcc/2 as voltage reference instead of ground; rearrange blocks
2022-04-16 ignore #auto_saved_files#
2022-04-16 add common-mode filter on input as well
2022-04-16 reassign numbers; add filtering to voltage reference
2022-04-16 add inductor to power filtering
2022-04-16 tweak positioning; write 100nF as 0.1uF
2022-04-16 tweak positioning
2022-04-16 set 555 pulse width values; misc tweaks
2022-04-16 tweak cap values (going to use film even for decoupling); add component notes
2022-04-16 additional component notes
2022-04-16 more positioning tweaks
2022-04-18 drive transmitter at 50% power, like "official" implementation (which avoids unusual resistor values)
2022-04-20 add input dc filtering, increase input impedance to 10k (per apparent de facto standard)
2022-04-20 add notes about single-ic instrumentation amplifiers
2022-04-20 add what seems like an absurd amount of power filtering
2022-04-21 only use 2 filter stages on power input
    in theory, 2 stages attenuates even 30Hz noise by -25dB (~300x),
    which ought to be enough for anyone
2022-04-23 remove common-mode filtering from input
    it doesn't seem to do much in practice, and in theory we should have
    very good common-mode rejection so it shouldn't be necessary
2022-04-23 switch to difference amplifier instead of instrumentation amplifier
    i'm still running into what seem like DC offset/saturation issues
    this difference amplifier should have every stage centered on the
    virtual ground at VCC/2, which should avoid this problem
    also, buffer the output of the amplification stage since it seems to get
    loaded down by the 555 when it switches on (which makes no sense tbh)
    also, tweak some sizes to reduce bom count
2022-04-23 use dual-gang pot to match bias current; choose pot pins to match desired resistance @ 0%
2022-04-23 tweak note
2022-04-23 rearrange second gain stage so pot has linear effect on gain
    it's hard to find in-stock reverse-log pots, so just change the circuit
    to make it linear for linear pot input
    i don't think we need more than 100x gain anyways.
2022-04-24 add schottky diodes for input protection
2022-04-24 actually, this one goes to 11
2022-04-24 use audio plug switch to ground input when disconnected
2022-04-24 use smaller resistor values in amplification; add feeback caps to limit overshoot/oscillation
    datasheet recommends using smaller resistors, because larger ones can
    add poles at frequencies below the unity-gain bandwidth
    also recommends using a cap in parallel with feedback resistors over 5k
    this requires using a final gain stage instead of a buffer, but it seems
    like the timer triggering anomalies are due to the power rail dropping,
    so it likely wouldn't help anyways
2022-04-24 make pulse generation edge triggered instead of level triggered
2022-04-24 tweak notes
2022-04-25 switch back to instrumentation amplifier
    the difference amplifier loads down the input too much (requiring more
    gain), and i'm having oscillation problems (at lower gain than the
    instrumentation amplifier)
    it also seemed to have more noise, requires a more annoying dual-gang
    pot, etc.
    also: add a dc return path to ground, to really eliminate input offset
2022-04-25 add decoupling caps on 555 supply as well
2022-04-26 remove 10pF across transmitter LED drive resistor
    in testing this doesn't seem to affect the rise time of the voltage
    across the diode at all
    also, 10pF is _tiny_, there is likely to be about that much capacitance
    just in the traces leading to it...
    (and also, this reduces bom count)
2022-04-26 remove 555 Control Voltage decoupling caps
    the datasheet says this isn't necessary "in most instances" [when?]
    and it doesn't seem to make a difference in practice
    also, this cap would be used to reduce noise, but in this application it'll
    be in a metal enclosure, so it should be shielded from any significant
    outside noise
2022-04-26 use 1nF filter cap on high-pass pulse filter
    this generates a ~1us pulse on each falling edge. previously it was
    <1us, which didn't trigger the timer reliably
2022-04-26 set low-pass aliasing filter to fixed 10kHz, remove pot
    this doesn't really need to be adjustable. it's hard to even generate
    10kHz+ frequencies with a guitar. and even 10kHz is _very_ high, not
    that important to reproduce
2022-04-26 change input low-pass filter to 30kHz (1nF)
    this reduces bom count. we don't expect to see any frequencies this high
    on the input anyways, and what it's really there for is to filter out
    very high frequency noise that could cause the op-amps to oscillate. so
    the exact value isn't that important
2022-04-26 use normal diode for clamping positive pulse
    the reverse leakage current (or something) seems to be interfering with
    triggering when using a schottky
2022-04-26 also change input protection to normal diodes instead of schottky
    i suspect reverse leakage current will be a problem here too. and this
    reduces bom count. and i can find some examples of people using basic
    diodes (like the 1N4148) for op-amp input protection, so it should be
    fine
2022-04-27 start pcb, get components into rough positions
2022-04-28 finish routing "pcb"
    this is actually going to be on two proto boards, hence the weird layout
2022-04-28 re-place and re-route everything
    turns out, i need to orient the proto board the other way
    also, make edge connections for wires more consistent
2022-04-29 note that current gain pinout is for linear pot, although reverse log is desired
    apparently it's pretty much impossible to actually get a reverse log
    pot? which seems quite strange, surely i'm not the only one with 1/R
    gain
2022-04-29 re previous commit: actually, a linear pot is what we want
    a linear pot results in 1/x (hyperbolic) gain.
    this is closer to the logarithmic/exponential human perception of loudness
    than using a reverse log pot, which would make gain ~linear.
2022-05-05 tweak pcb layout to make it easier to protoboard
2023-04-03 use schottky for 555 output edge detection
    in practice, using a normal diode results in 1V overvoltage,
    which is well beyond the rated 0.3V
    a schottky brings this down to 0.5V, which is still beyond the rating,
    but is a significant improvement
2023-04-03 add second edge detection capacitor
    this is necessary to extend the pulse enough so it's still detected
    after the previous schottky commit
    schottky leakage current must be quite significant if this is
    necessary...though i suppose it is only 1nF
    after reproducing the issue, i remember i originally discovered that a
    schottky here would break things, but i forgot, and evidently did not
